KV = "4.1.37"
GCCREV = "4.9.1"
SRCDATE = "20170228"

require et1x000-dvb-modules.inc

SRC_URI[md5sum] = "aeec5c768a3f2fb2458a6747b26ce2c2"
SRC_URI[sha256sum] = "0e1a6e5b408a1675a5a9c2c0a330d805e251a9934bea0467a2f3d50d9ff3face"
